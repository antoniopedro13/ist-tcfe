R1 1 2 1.031712e+03
R2 3 2 2.039469e+03
R3 2 5 3.107565e+03
R4 5 0 4.130271e+03
R5 5 6 3.023849e+03
R6 0 9 2.057322e+03
R7 7 8 1.039732e+03
Vs 1 0 0.0 ac 1.0 sin(0 1 1000)
Ca 6 8 1.022605e-06
Gb 6 3 (2,5) 7.158337e-03
Ve 9 7 0
Hc 5 8 Ve 8.366406e+03
.op
.ic v(6)=5.710299e+00 v(8)=-2.879114e+00
