R1 1 2 1.006765e+03
R2 3 2 2.033032e+03
R3 2 5 3.033913e+03
R4 5 0 4.003128e+03
R5 5 6 3.131011e+03
R6 0 9 2.093899e+03
R7 7 8 1.017744e+03
Vs 1 0 0
Ca 6 8 1.035361e-06
Gb 6 3 (2,5) 7.272764e-03
Ve 9 7 0
Hc 5 8 Ve 8.170065e+03
.op
.ic v(6)=5.852787e+00 v(8)=-3.074760e+00
